# IAR project RT106X.ewp, settings and files
configuration nor_sdram_zf_dtcm (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa181,Pe2464
  ICCARM.CCIncludePath2: ..\..\src; ..\..\..\Libraries\seekfree_libraries; ..\..\..\Libraries\nxp_libraries\CMSIS\Include; ..\..\..\Libraries\nxp_libraries\cmsis_drivers; ..\..\..\Libraries\nxp_libraries\drives; ..\..\..\Libraries\nxp_libraries\startup; ..\..\..\Libraries\nxp_libraries\startup\MDK-ARM; ..\..\..\Libraries\nxp_libraries\utilities; ..\..\..\Libraries\nxp_libraries\utilities\debug_console; ..\..\..\Libraries\nxp_libraries\utilities\str; ..\..\..\Libraries\nxp_libraries\xip; ..\..\..\Libraries\nxp_libraries\deceive; ..\..\..\Libraries\nxp_libraries\components\serial_manager; ..\..\..\Libraries\nxp_libraries\components\uart; ..\..\..\Libraries\nxp_libraries\components\lists; ..\..\..\Libraries\nxp_libraries\components\osa; ..\..\..\Libraries\nxp_libraries\components\serial_manager\usb_cdc_adapter; ..\..\..\Libraries\nxp_libraries\middleware\usb\include; ..\..\..\Libraries\nxp_libraries\middleware\usb\phy; ..\..\..\Libraries\nxp_libraries\middleware\usb\device; ..\..\..\Libraries\nxp_libraries\middleware\sdmmc\inc; ..\..\..\Libraries\nxp_libraries\middleware\sdmmc\port; ..\..\..\Libraries\nxp_libraries\middleware\sdmmc\port\usdhc; ..\..\..\Libraries\nxp_libraries\middleware\sdmmc\port\usdhc\interrupt; ..\..\..\Libraries\nxp_libraries\middleware\sdmmc\src; ..\..\..\Libraries\nxp_libraries\middleware\fatfs\source; ..\..\..\Libraries\nxp_libraries\middleware\fatfs\source\fsl_sd_disk; ..\..\..\Libraries\seekfree_libraries\common; ..\..\..\Libraries\seekfree_libraries\board; ..\..\..\Libraries\seekfree_peripheral; ..\..\..\Libraries\rttherad_libraries\components\finsh; ..\..\..\Libraries\rttherad_libraries\include; ..\..\..\Libraries\rttherad_libraries\include\libc; ..\..\..\Libraries\rttherad_libraries; ..\..\..\Libraries\rttherad_libraries\components\utilities\ulog; ..\..\..\Libraries\rttherad_libraries\components\utilities\utest; ..\..\..\Libraries\rttherad_libraries\components\cplusplus; ..\..\src\HalLibs; ..\..\src\Match; ..\..\src\ONNX; ..\..\src\Neural
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\..\Libraries\librares\startup\IAR-ARM; ..\..\..\Libraries\rttherad_libraries\libcpu\arm\cortex-m7
  OBJCOPY.OOCOutputFile: RT106X.srec
  ILINK.IlinkOutputFile: RT106X.out
  ILINK.IlinkIcfFile: ..\..\IAR\icf\MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../../../Libraries/seekfree_libraries/board/: board.c board.h clock_config.c pin_mux.c
  group fsl_cpt
    ../../../Libraries/nxp_libraries/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    ../../../Libraries/nxp_libraries/components/lists/: generic_list.c generic_list.h
    ../../../Libraries/nxp_libraries/components/uart/: lpuart_adapter.c uart.h
    ../../../Libraries/nxp_libraries/components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group fsl_drives
    ../../../Libraries/nxp_libraries/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_ocotp.c fsl_ocotp.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group fsl_fatfs
    ../../../Libraries/nxp_libraries/middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
    ../../../Libraries/nxp_libraries/middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group fsl_sdmmc
    ../../../Libraries/nxp_libraries/middleware/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdio.c fsl_sdmmc_common.c
    ../../../Libraries/nxp_libraries/middleware/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
    ../../../Libraries/nxp_libraries/middleware/sdmmc/port/usdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../../Libraries/nxp_libraries/middleware/sdmmc/port/: fsl_sdmmc_event.h
  group fsl_usb
    ../../../Libraries/nxp_libraries/middleware/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../../Libraries/nxp_libraries/middleware/usb/device/: usb_device.h usb_device_dci.c usb_device_dci.h usb_device_ehci.c usb_device_ehci.h
    ../../../Libraries/nxp_libraries/components/serial_manager/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
    ../../../Libraries/nxp_libraries/middleware/usb/phy/: usb_phy.c usb_phy.h
  group fsl_utilities
    ../../../Libraries/nxp_libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_notifier.h fsl_sbrk.c fsl_shell.c fsl_shell.h usb_device_config.h
    ../../../Libraries/nxp_libraries/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../Libraries/nxp_libraries/utilities/str/: fsl_str.c fsl_str.h
  group hal_libs
    ../../src/HalLibs/: agile_button.c agile_button.h easyblink.c easyblink.h encoder.hpp inc_pid.hpp mixLEDs.hpp motor.hpp openart.hpp pos_pid.hpp ser_pid.hpp servo.hpp wheel.hpp
  group remote_ctrl
    ../../src/HalLibs/: PS2.cpp PS2.h
  group rt1064_startup
    ../../../Libraries/nxp_libraries/xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
    ../../../Libraries/nxp_libraries/deceive/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
    ../../../Libraries/seekfree_peripheral/: RT106X_config.h
    ../../../Libraries/nxp_libraries/startup/IAR-ARM/: startup_MIMXRT1064.s
  group rtthread_cpp
    ../../../Libraries/rttherad_libraries/components/cplusplus/: crt_init.c cxx_crt.cpp cxx_Mutex.cpp cxx_Semaphore.cpp cxx_Thread.cpp
  group rtthread_cpt
    ../../../Libraries/rttherad_libraries/components/finsh/: cmd.c finsh.h finsh_api.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_file.c shell.c shell.h symbol.c
    ../../../Libraries/rttherad_libraries/components/utilities/ulog/backend/: console_be.c
    ../../../Libraries/rttherad_libraries/components/utilities/ulog/syslog/: syslog.c syslog.h
    ../../../Libraries/rttherad_libraries/components/utilities/ulog/: ulog.c ulog.h ulog_def.h
  group rtthread_inc
    ../../../Libraries/rttherad_libraries/include/libc/: libc_dirent.h libc_errno.h libc_fcntl.h libc_fdset.h libc_ioctl.h libc_limits.h libc_signal.h libc_stat.h libc_stdio.h
    ../../../Libraries/rttherad_libraries/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
  group rtthread_lib
    ../../../Libraries/rttherad_libraries/libcpu/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group rtthread_src
    ../../../Libraries/rttherad_libraries/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group sf_device
    ../../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h SEEKFREE_MT9V03X_CSI.c SEEKFREE_MT9V03X_CSI.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_W25QXXJV.c SEEKFREE_W25QXXJV.h
  group sf_libs
    ../../../Libraries/seekfree_libraries/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
    ../../../Libraries/seekfree_libraries/: interrupt.c zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_csi.c zf_csi.h zf_flash.c zf_flash.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_iomuxc.c zf_iomuxc.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_qtimer.c zf_qtimer.h zf_rom_api.c zf_rom_api.h zf_sdcard.c zf_sdcard.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_uart.c zf_uart.h zf_usb_cdc.c zf_usb_cdc.h zf_vector.c zf_vector.h
  group user
    ../../src/: ctrl_chassis.cpp ctrl_chassis.h ctrl_dymparam.cpp ctrl_dymparam.h ctrl_inoutdev.cpp ctrl_inoutdev.h ctrl_openart.cpp ctrl_steer.cpp ctrl_steer.h display_ui.cpp f_cross.cpp f_curve.cpp f_elems.cpp f_elems.h f_garage.cpp f_loop.cpp f_qrcode.cpp f_ramp.cpp f_yroad.cpp hw_config.h img_proc.cpp img_proc.h main.cpp main.h test.cpp util.cpp
